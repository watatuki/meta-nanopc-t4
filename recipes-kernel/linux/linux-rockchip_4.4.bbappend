# Copyright (C) 2020, wata2ki@gmail.com
# Refer to friendlyarm repositories 
# Released under the MIT license (see COPYING.MIT for the terms)

SRCREV = "595acbae9d1e03e39d0ebbb22226b061f5682be7"
SRC_URI = " \
	git://github.com/friendlyarm/kernel-rockchip.git;branch=nanopi4-linux-v4.4.y; \
	file://cgroups.cfg \
"

